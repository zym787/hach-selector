# Keil uVision project STM32F_VALVE.uvprojx, settings and files
target VALVE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VALVE +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SRC\APP;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\usart;..\SRC\CoreSupport;..\SRC\HARDWARE\usinterface;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\valve;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\Modbus;..\SRC\HARDWARE\protExt;..\SRC\HARDWARE\signal
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../SRC/APP/: startup_stm32f10x_md.s
  group APP
    ../SRC/APP/: main.c
  group HARDWARE
    ../SRC/HARDWARE/valve/: valve.c
    ../SRC/HARDWARE/EEPROM/: EEP24Serial.c
    ../SRC/HARDWARE/Modbus/: modbus.c ModBusCrc16.c
    ../SRC/HARDWARE/usinterface/: usFunc.c USINTF_CR-0.lib
    ../SRC/HARDWARE/motor/: Smotor.lib
    ../SRC/HARDWARE/protExt/: protExt.c
    ../SRC/HARDWARE/signal/: signal.c
  group SYSTEM
    ../SRC/SYSTEM/delay/: delay.c
    ../SRC/SYSTEM/sys/: sys.c
    ../SRC/SYSTEM/usart/: usart.c
    ../SRC/SYSTEM/timer/: timer.c
